linux-socfpga_%.bbappend